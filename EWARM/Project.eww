<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\room_temp_monitor.ewp</path>
  </project>
  <batchBuild />
</workspace>
